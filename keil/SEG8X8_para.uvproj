# Keil uVision project SEG8X8_para.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SEG8X8_para +hex
  c flags: Optimize=3 SizeSpeed=1
  group Source Group 1
    ../src/: main.c ds1302.c ds1302.h
